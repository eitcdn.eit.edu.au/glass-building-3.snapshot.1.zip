# Autodesk Inventor assembly: new building
## iProperties
Created: 2018-12
Part Number: new building
Document SubType Name: Assembly
Designer: Harindersingh
Author: Harindersingh
